# Keil uVision project PRO.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PRO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user_h;..\..\lib.h
  group User
    ../user_c/: IAP15W4K32S4_IT.c pro.c
  group LIB
    ../../lib.c/: adc.c delay.c eeprom.c exint.c io.c uart.c
